<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\nucleo-f746zg-ad.ewp</path>
  </project>
  <batchBuild />
</workspace>
