<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F746ZGT6U.ewp</path>
  </project>
  <batchBuild />
</workspace>
