<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\A1902_STM32F730V8T6_BOOT.ewp</path>
  </project>
  <batchBuild />
</workspace>
