# IAR project FlashSTM32F7xx_QSPI.ewp, settings and files
configuration STM32F7xx_QSPI_MICRON (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756VG ST STM32F756VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: DRV_GD
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; ; CMSIS\Device\ST\STM32F7xx\Include\; QSPI\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashSTM32F7xx_QSPI.bin
  ILINK.IlinkOutputFile: FlashSTM32F7xx_QSPI_GD.out
  ILINK.IlinkIcfFile: FlashSTM32F7xx_64kB.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration STM32F7xx_QSPI_WINBOND (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DRV_WINBOND
  OBJCOPY.OOCOutputFile: FlashSTM32F7xx_QSPI_WINBOND.bin
  ILINK.IlinkOutputFile: FlashSTM32F7xx_QSPI_WINBOND.out
  group (top)
    ./: FlashSTM32F7xx_QSPI.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group Other
    ./: FlashSTM32F7xx_64kB.icf FlashSTM32F7xx_QSPI.mac
  group QSPI
    QSPI/: qspi_flash.c qspi_gd.c qspi_micron.c qspi_spansion.c qspi_utils.c qspi_winbond.c
